# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\ ; Lib\CMSIS\Include; Lib\CMSIS\ST\STM32F0xx\Include; Lib\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Header
    ./: gpio.h main.h tm_stm32f4_nrf24l01.h util.h spi1.h
  group Source
    ./: gpio.c main.c tm_stm32f4_nrf24l01.c spi1.c
  group BSP
    ./Lib/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./Project/Demonstration/: stm32f0xx_conf.h
    ./Lib/CMSIS/ST/STM32F0xx/Include/: system_stm32f0xx.h
    ./Lib/CMSIS/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group STM_Lib
    ./Lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
software components: CMSIS:CORE 5.0.0
